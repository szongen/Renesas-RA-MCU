# Keil uVision project FSP_Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA2E1A7 Renesas
  pack: Renesas.RA_DFP.4.5.0
  cpu: CPUTYPE("Cortex-M23")      CLOCK(12000000) ELITTLE
  output: FSP_Project +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\driver
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group Driver
    ./driver/: hal_dht11.c hal_tube.c hal_flash.c multi_button.c
software components: Flex Software:RA Configuration 1.0.0
